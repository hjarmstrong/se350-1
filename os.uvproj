# Keil uVision project os.uvproj, settings and files
target OS (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: os
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./startup/: startup_LPC17xx.s
  group src
    ./src/: main.c printf.c printf.h rtx.c rtx.h stdefs.h uart_polling.c uart_polling.h
  group sys
    ./sys/: system_LPC17xx.c
  group mem
    ./src/mem/: mem.c mem.h
